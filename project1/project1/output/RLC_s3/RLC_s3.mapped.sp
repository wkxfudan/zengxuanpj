Vin N_in1  	0 		5
Rseg_X1 n_in1 N_1_X1 3
Lseg_X1 n_1_X1 n_in2 2
Cseg_X1 n_in2 0 4
Rseg_X2 N_in2 N_1_X2 3
Lseg_X2 n_1_X2 N_in3 2
Cseg_X2 N_in3 0 4
Rseg_X3 n_in3 N_1_X3 3
Lseg_X3 n_1_X3 n_out 2
Cseg_X3 n_out 0 4
Cl	n_out	0		2
