Vin 1  	0 		5
Ls1_X1 1 0 3
Ls2_X1 3 4 2
K2_X1 Ls1_X1 Ls2_X1 0.5
Rs_X1 1 3 5
Ls1_X2 2 0 3
Ls2_X2 5 4 2
K2_X2 Ls1_X2 Ls2_X2 0.5
Rs_X2 2 5 5
Cs	3	5	10
Ls1	1	2	1
Rs	0	2	1
